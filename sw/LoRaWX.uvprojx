# Keil uVision project LoRaWX.uvprojx, settings and files
target LoraWX (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LoRaWX +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L072xx,USE_B_L072Z_LRWAN1,USE_HAL_DRIVER
  c misc: --C99
  c include: .\lib;.\hal;.\hal\legacy;.\lib\region;..\sw;.\sensors
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Config
    ./: Commissioning.h mlm32l0xx_hw_conf.h config.h
  group LoRa
    ./lib/: soft-se.c cmac.c aes.c systime.c trace.c queue.c utilities.c timeServer.c low_power_manager.c LoRaMac.c lora-test.c LoRaMacClassB.c LoRaMacSerializer.c LoRaMacAdr.c LoRaMacParser.c LoRaMacConfirmQueue.c LoRaMacFCntHandler.c LoRaMacCommands.c LoRaMacCrypto.c lora.c b-l072z-lrwan1.c mlm32l07x01.c sx1276.c
    ./lib/region/: RegionRU864.c RegionUS915.c RegionKR920.c RegionIN865.c RegionEU868.c RegionEU433.c RegionCommon.c RegionCN779.c RegionCN470.c RegionAU915.c RegionAS923.c Region.c
  group STM32
    ./: startup_stm32l072xx.s
    ./lib/: system_stm32l0xx.c
    ./hal/: stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c
  group WXapp
    ./: bsp.c debug.c hw_gpio.c hw_rtc.c hw_spi.c main.c vcom.c mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c
  group Sensors
    ./sensors/: BME280.c HPM.c loradunchy_adc.c sensors.c sht31.c SI7013.c STC3100.c TMP75.c VEML6030.c VEML6075.c
